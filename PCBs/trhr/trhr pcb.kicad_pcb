# Repository SchibleyJ/trhr-prism

File README.md:

# trhr-prism
A "top row home row" layout and PCB for the [GRAM PRI$M](https://github.com/GrammyMoney/GRAM-PRISM/).

## Comparison of different layouts:

This explanation will compare the "traditional prism layout," the "Swift layout," and what I'm simply calling the "top row home row (TRHR) layout."

Here is the traditional prism layout:

It is essentially just based on the classic B0XX design which many digital controllers share.

Here is the Swift layout:

It is a unique design commissioned by the player Swift to rest your fingers on the top row of buttons rather than the bottom, similar to the [HTangl Controller](https://www.htangl.com/layout).

Here is the Top Row Home Row layout:

It is a modification of the Swift layout to adjust the position of the c-stick cluster.

Here is a comparison between each of the 3 layouts:

Traditional vs Swift:

Swift vs TRHR:

Traditional vs TRHR:

## Explanation of TRHR's changes:

Overall, the Swift layout is a very impressive and comfortable design.  However, the one place it can be improved is with the placement of the c-stick cluster.  As you can see by looking at "Traditional vs Swift," the c-stick cluster's position was not adjusted at all, despite the home row being moved up substantially (remember, the Swift layout's homerow is on top).  This puts the cluster below where it was originally designed to be relative to your hand.

TRHR fixes this by moving the c-stick cluster up and to the left, recreating the original spacing/distance of the traditional design while keeping the benefits of the Swift layout.  You can see this change by looking at "Swift vs TRHR" and understand the intended spacing by looking at "Traditional vs TRHR."

TRHR also includes an MS button which was excluded from the original Swift layout.  I've included additional files labeled "TRHR-S" which exclude the MS button as well.  To clarify, the standard TRHR layout has an MS button while TRHR-S does not.

*One final note if you're looking to try this layout yourself: as you can see in the documentation for the original [HTangl layout](https://www.htangl.com/layout), one of the major benefits of using closer spaced buttons and a top row home row is that you can wavedash using X and R instead of Y and R.  This holds true with the TRHR layout and is the method that gives the most benefit over just using the traditional prism layout in the first place.* 

*Here is the suggested layout for reference:*

## KiCad design PCBs/trhr/trhr pcb.kicad_pcb

Board: 2 copper layers, 14 parts (1 on the bottom side), 14 nets.

Parts:
CH8, CH9, CH10, CH11, CH12, CH13, CH14, CH15, CH16, CH17, CH18, CH19, CH20: choc_SW_HS; Kailh_socket_PG1350
J5: FFC Connector; TE_1-84953-4_1x14-1MP_P1.0mm_Horizontal

Connections:
A: CH17.1, J5.12
B: CH11.1, J5.3
C_DN: CH13.1, J5.11
C_LT: CH12.1, J5.13
C_RT: CH15.1, J5.10
C_UP: CH9.1, J5.14
GND: CH8.2, CH9.2, CH10.2, CH11.2, CH12.2, CH13.2, CH14.2, CH15.2, CH16.2, CH17.2, CH18.2, CH19.2, CH20.2, J5.1, J5.MP (MountPin)
LS: CH16.1, J5.6
MS: CH19.8 (1), J5.8
R: CH8.1, J5.2
UP: CH20.1, J5.9
X: CH14.1, J5.5
Y: CH10.1, J5.4
Z: CH18.1, J5.7
